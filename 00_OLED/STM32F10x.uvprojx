# Keil uVision project STM32F10x.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Hard;.\User;.\System;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\STM32F10x;.\Hard\LED\src;.\Hard\LED\LED_Drive_STM32F1;.\Hard\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h README.md
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../Libraries/CMSIS/STM32F10x/: stm32f10x.h
    ../Libraries/CMSIS/STM32F10x/startup/: startup_stm32f10x_md.s
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h
  group Hard
    ./Hard/LED/src/: LED.c
    ./Hard/LED/LED_Drive_STM32F1/: LED_Drive.c
    ./Hard/: OLED.c
